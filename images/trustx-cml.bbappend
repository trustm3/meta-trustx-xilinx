inherit trustmezynq
